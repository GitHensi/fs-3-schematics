# Repository GitHensi/fs-3-schematics

## KiCad design BMS/BMS.kicad_pcb

Board: 2 copper layers, 57.4 x 171.2 mm, 95 parts (0 on the bottom side), 78 nets.

Parts:
C1: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5, C8, C9, C10, C11, C13, C14: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C6, C7: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C12: 15pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3, D4, D5, D6, D7, D8, D9: LH R974-LP-1; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1, F2, F3, F4, F5, F6, F7: Polyfuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
H1, H2, H3, H4, H5: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1: Conn_01x02_Pin; Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal
J2, J3: IsoSPI; Molex_Nano-Fit_105313-xx02_1x02_P2.50mm_Horizontal
J4, J5, J6, J7, J8, J9: JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: HM2113ZNL; HM2113ZNLT
Q1: NSV1C201MZ4; SOT-223
Q3, Q4, Q5, Q6, Q7, Q8: BSS308PE; SOT-23
R1, R2, R18, R22, R26, R30, R36, R45: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 100; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R4, R7, R8, R37, R38, R39: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5: 200; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R51: 160; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13: 680; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R15, R19, R23, R27, R31, R42: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R20, R24, R28, R34, R43: 33; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R17, R21, R25, R29, R35, R44: 3.3k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R32: 402; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R33: 2.2k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R40, R41: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW2: A6H-4101; SW_A6H-4101_OMR
U2: ADG708; TSSOP-16_4.4x5mm_P0.65mm
U3: LTC6811IG-2-TRPBF; LTC6811-2

Connections:
/BB0/B#+1: D7.1 (K), F2.1, Q8.2 (S), R34.1, R45.2
/BB1/B#+1: D6.1 (K), F3.1, Q7.2 (S), R28.1, R36.2
/BB2/B#+1: D5.1 (K), F4.1, Q6.2 (S), R24.1, R30.2
/BB3/B#+1: D4.1 (K), F5.1, Q5.2 (S), R20.1, R26.2
/BB4/B#+1: D3.1 (K), F6.1, Q4.2 (S), R16.1, R22.2
/BB5/B#+1: F7.1, Q3.2 (S), R1.2, R2.2, R18.2
/C0: C2.1, C14.2, R3.1, U3.26 (C0)
/C1: C11.2, C14.1, R45.1, U3.24 (C1)
/C2: C10.2, C11.1, R36.1, U3.22 (C2)
/C3: C9.2, C10.1, R30.1, U3.14 (C6), U3.16 (C5), U3.18 (C4), U3.20 (C3)
/C7: C8.2, C9.1, R26.1, U3.12 (C7)
/C8: C5.2, C8.1, R22.1, U3.10 (C8)
/C9-12: C5.1, R18.1, U3.2 (C12), U3.4 (C11), U3.6 (C10), U3.8 (C9)
/DRV: Q1.1 (B), U3.38 (DRIVE)
/S1: R44.1, U3.25 (S1)
/S2: R35.1, U3.23 (S2)
/S3: R29.1, U3.21 (S3)
/S7: R25.1, U3.13 (S7)
/S8: R21.1, U3.11 (S8)
/S9: R17.1, U3.9 (S9)
/V+: R1.1, U3.1 (V+)
/extIsoSPI_N: J2.1, J3.1, R41.1
/extIsoSPI_P: J2.2, J3.2, R40.1
A0: R8.1, SW2.4, U3.45 (A0)
A1: R7.1, SW2.3, U3.46 (A1)
A2: R4.1, SW2.2, U3.47 (A2)
IBIAS: R12.2, U3.44 (SDO(IBIAS))
ICMP: R12.1, R13.2, U3.43 (SDI(IMCP))
IsoSPI_N: C12.1, L1.6, R5.1, U3.41 (CSB(IMA))
IsoSPI_P: L1.4, R32.1, SW2.1, U3.42 (SCK(IPA))
MUX_A0: R37.1, U2.1 (A0), U3.27 (GPIO1)
MUX_A1: R38.1, U2.16 (A1), U3.28 (GPIO2)
MUX_A2: R39.1, U2.15 (A2), U3.29 (GPIO3)
unnamed: C1.1, Q1.2 (C), Q1.4 (C), R2.1
unnamed: C12.2, R32.2
unnamed: C13.1, L1.5
unnamed: D1.2 (A), R6.1
unnamed: D3.2 (A), R15.2
unnamed: D4.2 (A), R19.2
unnamed: D5.2 (A), R23.2
unnamed: D6.2 (A), R27.2
unnamed: D7.2 (A), R31.2
unnamed: D8.2 (A), R42.2
unnamed: D9.2 (A), R51.1
unnamed: D9.1 (K), U3.33 (GPIO5)
unnamed: F2.2, H1.1
unnamed: F3.2, H2.1
unnamed: F4.2, H3.1
unnamed: F5.2, H4.1
unnamed: F6.2, H5.1
unnamed: F7.2, J1.1
unnamed: F1.2, J1.2
unnamed: J4.2, U2.4 (S1)
unnamed: J5.2, U2.5 (S2)
unnamed: J6.2, U2.6 (S3)
unnamed: J7.2, U2.7 (S4)
unnamed: J8.2, U2.12 (S5)
unnamed: J9.2, U2.11 (S6)
unnamed: L1.1, R41.2
unnamed: L1.3, R40.2
unnamed: Q3.3 (D), R15.1, R16.2
unnamed: Q3.1 (G), R17.2
unnamed: Q4.3 (D), R19.1, R20.2
unnamed: Q4.1 (G), R21.2
unnamed: Q5.3 (D), R23.1, R24.2
unnamed: Q5.1 (G), R25.2
unnamed: Q6.3 (D), R27.1, R28.2
unnamed: Q6.1 (G), R29.2
unnamed: Q7.3 (D), R31.1, R34.2
unnamed: Q7.1 (G), R35.2
unnamed: Q8.3 (D), R42.1, R43.2
unnamed: Q8.1 (G), R44.2
unnamed: R5.2, SW2.8
unnamed: C7.2, U3.35 (VREF1)
unnamed: C6.2, U3.34 (VREF2)
TEMP: R33.1, U2.8 (D), U3.32 (GPIO4)
V-: C1.2, C2.2, C3.2, C6.1, C7.1, C13.2, D1.1 (K), D8.1 (K), F1.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, R3.2, R4.2, R7.2, R8.2, R13.1, R43.1, U2.3 (VSS), U2.14 (GND), U3.30 (V-), U3.31 (V-), U3.36 (DTEN), U3.48 (A3)
VREG: C3.1, Q1.3 (E), R6.2, R33.2, R37.2, R38.2, R39.2, R51.2, SW2.5, SW2.6, SW2.7, U2.2 (EN), U2.13 (VDD), U3.37 (VREG), U3.40 (ISOMD)

## Commit log

2024-10-19 Update BMS.kicad_pcb
    BMS packaging on the old board form factor.
2024-10-21 Update BMS.kicad_pcb
    updated J1-3 to fit the required 20mm clearances
